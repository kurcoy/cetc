# IAR project ManchesterCode.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\DLIB\; $TOOLKIT_DIR$\\tutor\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgtiny45.xcl
  XLINK.XExtraOptions: -Ointel-extended,(XDATA)=.eep; -Ointel-extended,(CODE)=.A90; -Ointel-extended,(CODE)=.hex
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x30
  General.SCCStackSize: 0x60
  General.SCRStackSize: 64
  General.LCNearHeapSize: 0x30
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\DLIB\; Manchester\
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    ./: main.c
  group Manchester
    Manchester/: ManchesterCode.c ManchesterCode.h ManchesterInit.c ManchesterInit.h
